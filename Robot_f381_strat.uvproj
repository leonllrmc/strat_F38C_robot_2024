# Keil uVision project Robot_f381_strat.uvproj, settings and files
target Robot (MCS-51)
  device: C8051F381 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: Robot_f381_strat
  c flags: SizeSpeed=1
  c include: .\CFPT_uC_lib
  group Sources
    ./: Function.c INT.C main.c rs232.c STARTUP.A51 init_f381.c
  group Lib
    ./CFPT_uC_lib/: PCA9685.c SMBUS.c
